# Keil uVision project 40_fsmc__lcd_rigister .uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\keil5\pack\ARM\CMSIS\5.9.0\CMSIS\Core\Include;.\Hardware\LED;.\Hardware\KEY;.\Hardware\USART;.\Hardware\I2C;.\Intertface\EEPROM;.\Hardware\SPI;.\Intertface\FLASH;.\Hardware\FSMC;.\40_fsmc__lcd_rigister\Code;.\40_fsmc__lcd_rigister\Start;.\Intertface\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./40_fsmc__lcd_rigister/Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Code
    ./40_fsmc__lcd_rigister/Code/: delay.c delay.h main.c
  group Hardware/LED
    ./Hardware/LED/: led.c led.h
  group Hardware/KEY
    ./Hardware/KEY/: key.c key.h
  group Hardware/UASRT
    ./Hardware/USART/: usart.c
  group Hardwaer/I2C
    ./Hardware/I2C/: i2c.c i2c.h
  group Interface/EEPROM
    ./Intertface/EEPROM/: m24c02.c m24c02.h
  group Hardware/SPI
    ./Hardware/SPI/: spi.c spi.h
  group Interface/FLASH
    ./Intertface/FLASH/: flash.c flash.h
  group Hardware/FSMC
    ./Hardware/FSMC/: fsmc.c
  group Interface/LCD
    ./Intertface/LCD/: lcd.c LCD_Front.c lcd.h
